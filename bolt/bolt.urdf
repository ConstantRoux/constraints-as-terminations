Commit message: fix bug (mass of feet was null)

File: bolt/bolt.urdf (robot description, URDF)
Before this commit: robot bolt, 9 links, 8 joints
Links:
- link FL_FOOT: mass 0.00000000 -> 0.00693606
- link FR_FOOT: mass 0.00000000 -> 0.00693606
